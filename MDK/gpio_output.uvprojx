# Keil uVision project gpio_output.uvprojx, settings and files
target gpio_output_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L130J8TA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\source;..\common;..\driver\inc;..\BSP\inc;..\DEV\inc;..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../common/: interrupts_hc32l13x.c system_hc32l13x.c
  group driver
    ../driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group BSP
    ../BSP/src/: bsp_tm3100_led.c bsp_gpio.c bsp_rtc.c bsp_sys.c bsp_adc.c bsp_time_capture.c bsp_iic.c bsp_lpm.c
  group DEV
    ../DEV/src/: led_panel.c drv_input.c led_panel_map.c drv_rtc.c dev_speed_rpm.c drv_adc.c drv_eeprom.c
  group APP
    ../APP/src/: app_vehicle.c
  group source
    ../source/: main.c
software components: CMSIS:CORE 5.4.0
